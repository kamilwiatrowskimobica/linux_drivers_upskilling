## 10_read_irq/kernel_module/Config.in
```kconfig
config BR2_PACKAGE_KERNEL_MODULE
    bool "kernel module"
    depends on BR2_LINUX_KERNEL
    help
        Custom module.
```
